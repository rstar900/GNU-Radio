options:
  parameters:
    author: Rachit Garg
    description: Equalizer for adjusting gains of voice WAV file
    generate_options: qt_gui
    id: equalizer
    output_language: python
    title: Equalizer
  states: {}

blocks:
- name: gain_high
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    label: Treble
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain_low
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0,1,1)
    label: Bass
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain_mid
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,1)
    label: Midrange
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain_low
    high_cutoff_freq: '400'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain_mid
    high_cutoff_freq: '2600'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain_high
    high_cutoff_freq: '10000'
    low_cutoff_freq: '2600'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/rstar900/Practical_SDR/getting_started_sdr-main/getting_started_sdr-main/ch_05/HumanEvents_s32k.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_1, '0', blocks_add_xx_0, '1']
- [band_pass_filter_2, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
